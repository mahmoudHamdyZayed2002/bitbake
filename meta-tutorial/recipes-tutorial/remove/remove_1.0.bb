DESCRIPTION = "I am the first recipe"
PR = "r2"
do_build () {
  echo from remove recipes
  rm -rf BUILD
}
